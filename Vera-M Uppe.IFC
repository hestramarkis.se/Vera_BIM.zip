Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Vera-M.IFC
Time: 2024-10-25T08:24:51
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10059
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 10459
In: Default Storey
PredefinedType: ELEMENT; Material: DC01+ZE

# IfcBuildingElementProxy: 10460
In: Default Storey
PredefinedType: ELEMENT; Material: PETG Svart

# IfcBuildingElementProxy: 60181_100cm Dagny X
In: Default Storey
PredefinedType: ELEMENT; Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 60191_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 71156 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: DC01

# IfcBuildingElementProxy: 71157 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 71158_7,5
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Dagny-X-Väv_Uppe
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Motor-N_Ø35
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: hexa csunk raisedhd screw tapping_iso_ISO 14587 ST4.2x9.5-Type R-N (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
